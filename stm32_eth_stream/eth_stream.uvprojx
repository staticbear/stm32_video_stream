# Keil uVision project eth_stream.uvprojx, settings and files
target eth_stream (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eth_stream +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group sources
    ./sources/: eth_stream.c rcc_control.c rcc_control.h flash_control.c flash_control.h ethernet.c ethernet.h misc_func.c misc_func.h ov9655.c ov9655.h timers.c timers.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.3
